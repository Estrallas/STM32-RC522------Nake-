# Keil uVision project USART.uvprojx, settings and files
target USART (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAR +hex
  c flags: uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\NET\device\inc;..\NET\MQTT;..\NET\onenet\inc;..\NET\cJSON;..\HARDWARE\AD;..\HARDWARE\DS18B20;..\HARDWARE\GPRS;..\HARDWARE\iic2;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\MPU6050;..\HARDWARE\SGP30;..\HARDWARE\SIM900A;..\HARDWARE\USART2;..\HARDWARE\KALMAN;..\HARDWARE\TIMER4;..\HARDWARE\USART2;..\HARDWARE\WDG;..\HARDWARE\timer2;..\HARDWARE\Timer;..\HARDWARE\ESP8266;..\HARDWARE\SIM800L;..\HARDWARE\STMFLASH;..\HARDWARE\OLED;..\HARDWARE\MAX30102;..\HARDWARE\rc522_config;..\HARDWARE\rc522_function;..\HARDWARE\read_card;..\HARDWARE\MQ5;..\HARDWARE\TB6612;..\HARDWARE\RC522
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c timer_key.c timer_key.h
  group HARDWARE
    ../HARDWARE/RC522/: RC522.c
    ../HARDWARE/OLED/: oled.c oled.h
    ./: Servo.c Servo.h button4_4.c button4_4.h OLED_DATA.c OLED_DATA.h user_logic.h user_logic.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
